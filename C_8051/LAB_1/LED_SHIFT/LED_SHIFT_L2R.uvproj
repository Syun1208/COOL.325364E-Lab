# Keil uVision project LED_SHIFT_L2R.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LED_SHIFT_L2R +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: LED_SHIFT_L2R.c
